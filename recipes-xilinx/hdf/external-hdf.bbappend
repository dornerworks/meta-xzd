DESCRIPTION = "Set HDF variables for HDF recipe"

FILESEXTRAPATHS_append := "${THISDIR}/files"

HDF_VERSION = "2017.1.ES2"

HDF_BASE = "file://"
HDF_PATH = "xilinx-zcu102-${HDF_VERSION}.hdf"
