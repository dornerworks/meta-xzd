FILESEXTRAPATHS_prepend := "${THISDIR}/config:"

SRC_URI += "file://network_bridge.scc"
SRC_URI += "file://filesystem_overlay.scc"
SRC_URI += "file://version.scc"
