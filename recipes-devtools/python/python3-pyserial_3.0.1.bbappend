FILESEXTRAPATHS_prepend := "${THISDIR}/python3-pyserial:"

SRC_URI += "file://disable-input-flush-on-open.patch"
