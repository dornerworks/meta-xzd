FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += " \
    file://0001-cdrtools-native-remove-failing-root-check.patch \
    "
