FILESEXTRAPATHS_prepend := "${THISDIR}/patches:"

SRC_URI += "file://0001-Explicitly-instantiate-the-Cortex-A53s.patch"